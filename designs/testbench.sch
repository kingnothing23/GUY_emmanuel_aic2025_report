** sch_path: designs/testbench.sch
**.subckt testbench VREF
*.opin VREF
V1 VDD 0 1.8
R1 OUT 0 10k ac=10k m=1
x1 VDD VREF OUT 0 temo_effected_current_ref_vb
**.ends
.end
